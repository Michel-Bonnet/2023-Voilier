# Keil uVision project F103_Voilier01.uvprojx, settings and files
target Simu (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103_Voilier01
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\MyDrivers2023\include;..\MyServices2023
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Voilier01
    ./src/: principal.c
  group Drivers
    ../MyDrivers2023/include/: F103_USART.h F103_GTIM.h F103_IT.h F103_DMA.h F103_ADC.h F103_SYSTICK.h F103_GPIO.h F103_RCC.h F103_SPI.h F103_I2C.h DS1307.h ADXL345.h E6B2.h
    ../MyDrivers2023/source/: F103_SYSTICK.c F103_USART.c F103_DMA.c F103_ADC.c F103_GTIM.c F103_IT.c F103_GPIO.c F103_RCC.c F103_SPI.c F103_I2C.c DS1307.c ADXL345.c E6B2.c
  group Services
    ../MyServices2023/: Bordage.h Bordage.c Comm.h Comm.c Plateau.c Plateau.h Surveil.c Surveil.h
target Reel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: F103_Voilier01
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\MyDrivers2023\include;..\MyServices2023
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
